# Keil uVision project rt_thread.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F100R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt_thread
  AfterMake: fromelf --bin !L --output rt_thread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD_VL, USE_STDPERIPH_DRIVER
  c include: ..\app;..\bsp;..\common;..\cortex-m3;..\rt_thread\include;..\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep *.o(.rti_fn.*)
  group STM32_StdPeriph
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c misc.c stm32f10x_dma.c
    ../cortex-m3/: system_stm32f10x.c
  group Application
    ../app/: application.c startup.c
  group Cortex_M3
    ../common/: backtrace.c div0.c showmem.c dataqueue.c completion.c
    ../cortex-m3/: cpuport.c startup_stm32f10x_md_vl.s context_rvds.S
  group Kernel
    ../rt_thread/kernel/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group Bsp
    ../bsp/: board.c gpio.c led.c stm32f10x_it.c usart.c serial.c
